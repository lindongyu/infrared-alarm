<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>delay</name>
    <file>
      <name>$PROJ_DIR$\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\delay.h</name>
    </file>
  </group>
  <group>
    <name>exti</name>
    <file>
      <name>$PROJ_DIR$\exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\exti.h</name>
    </file>
  </group>
  <group>
    <name>search</name>
    <file>
      <name>$PROJ_DIR$\search.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\search.h</name>
    </file>
  </group>
  <group>
    <name>speaker</name>
    <file>
      <name>$PROJ_DIR$\speaker.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\speaker.h</name>
    </file>
  </group>
  <group>
    <name>TIM</name>
    <file>
      <name>$PROJ_DIR$\time.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\time.h</name>
    </file>
  </group>
  <group>
    <name>USER</name>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
  </group>
</project>



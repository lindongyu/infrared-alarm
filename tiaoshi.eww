<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x63A5;&#x6536;&#x8C03;&#x8BD5;.ewp</path>
  </project>
  <batchBuild/>
</workspace>



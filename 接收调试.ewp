# IAR project 接收调试.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: 接收调试.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group delay
    ./: delay.c delay.h
  group exti
    ./: exti.c exti.h
  group search
    ./: search.c search.h
  group speaker
    ./: speaker.c speaker.h
  group TIM
    ./: time.c time.h
  group USER
    ./: main.c
